INSTALL_TIMEZONE_FILE = "1"
DEFAULT_TIMEZONE = "Europe/Moscow"
