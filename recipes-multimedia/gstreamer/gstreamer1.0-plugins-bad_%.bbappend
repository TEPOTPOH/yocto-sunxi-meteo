PACKAGECONFIG:append = " v4l2codecs"
# for debugging pipline
PACKAGECONFIG:append = " kms gl"
